# Keil uVision project project.uvprojx, settings and files
target rt-thread_gd32f30x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-gd32f30x
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: GD32F30X_HD, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: ..\..\include;..\..\components\drivers\include;Libraries\CMSIS;..\..\libcpu\arm\cortex-m4;.;..\..\libcpu\arm\common;..\..\components\libc\compilers\common\extension;..\..\components\finsh;Libraries\GD32F30x_standard_peripheral\Include;drivers;..\..\components\libc\posix\io\stdio;..\..\components\drivers\include;Libraries\CMSIS\GD\GD32F30x\Include;..\..\components\libc\posix\io\poll;..\..\components\drivers\include;..\..\components\libc\compilers\common\include;..\..\components\drivers\spi\sfud\inc;..\..\components\drivers\spi;applications;..\..\components\drivers\include;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\drivers\include;..\..\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/sfud/src/: sfud.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    drivers/: drv_gpio.c drv_spi.c drv_i2c.c drv_spi_flash.c drv_usart.c board.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    Libraries/GD32F30x_standard_peripheral/Source/: gd32f30x_enet.c gd32f30x_exti.c gd32f30x_sdio.c gd32f30x_dac.c gd32f30x_pmu.c gd32f30x_bkp.c gd32f30x_exmc.c gd32f30x_spi.c gd32f30x_fwdgt.c gd32f30x_ctc.c gd32f30x_rtc.c gd32f30x_usart.c gd32f30x_rcu.c gd32f30x_can.c gd32f30x_i2c.c gd32f30x_timer.c gd32f30x_dma.c gd32f30x_crc.c gd32f30x_misc.c gd32f30x_fmc.c gd32f30x_gpio.c gd32f30x_adc.c gd32f30x_dbg.c gd32f30x_wwdgt.c
    Libraries/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    Libraries/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
software components: CMSIS:CORE 5.6.0
